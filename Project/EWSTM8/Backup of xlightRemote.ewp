# IAR project Backup of xlightRemote.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: xlightRemote.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: _global.h main.c MyMessage.h ProtocolParser.c ProtocolParser.h rf24l01.c rf24l01.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group STM8L Library
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_tim4.c
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x_clk.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_spi.h stm8l15x_tim4.h
